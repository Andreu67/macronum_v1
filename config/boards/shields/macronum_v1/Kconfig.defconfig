## config/boards/shields/macronum_v1/Kconfig.defconfig
```kconfig
if SHIELD_MACRONUM_V1

config ZMK_KEYBOARD_NAME
    default "macronum_v1"
    endif
```
